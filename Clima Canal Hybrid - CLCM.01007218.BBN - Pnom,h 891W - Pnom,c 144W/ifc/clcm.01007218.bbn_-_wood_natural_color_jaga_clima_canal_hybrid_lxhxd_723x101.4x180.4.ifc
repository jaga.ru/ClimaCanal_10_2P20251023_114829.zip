Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-14T09:36:36
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20181011_1500(x64) - Exporter 18.4.0.0 - ARCHICAD Connection 21.0.0.6007

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (4)
Name | FlowDirection | Pset_DistributionPortPipe, PortNumber | Pset_DistributionPortPipe, ConnectionType | MEPPortPipe, ProfileShape | OuterDiameter (mm) = ConnectorDiameter (mm) = MEPPortPipe, NominalWidth (mm) = MEPPortPipe, NominalHeight (mm)
 | SINK | Pset_DistributionPortDuct - PortNumber: 1; ConnectionType: NONE; MEPPortDuct - ProfileShape: RECTANGULAR; NominalWidth: 88 mm; NominalHeight: 40 mm
 | SOURCE | 2 | WELDED | ROUND | 15
 | SINK | 3 | WELDED | ROUND | 15
 | SOURCE | 4 | WELDED | ROUND | 20

# IfcEnergyConversionDevice: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4, RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga:clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4:1225051
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Construction - RSen_C_offset_from_wall: 0 mm; TBQen_C_SOg_ME_01: aluminium - clima canal_jaga; TBQen_C_SOg_ME_02: none_gen
Type - Dimensions - RSen_C_depth: 180.4 mm; RSen_C_diameter: 0 mm; RSen_C_height: 101.4 mm; RSen_C_length: 723 mm
Type - Electrical - RSen_E_c01_apparent_power: 0 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: yes; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power: 0 W; RSen_E_c01_power_factor: 0; RSen_E_c01_voltage: 230 V
Type - Identity Data - Assembly Code: 56.10.60.11; Description: jaga_clima canal hybrid_trench radiator; Manufacturer: Jaga; Model: Clima Canal Hybrid; RSen_C_code_article: CLCM.01007218.BNN; RSen_C_code_ETIM: Convectorradiator; RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC010152&classVersion=4; RSen_C_code_gtin: -; RSen_C_code_product: -; RSen_C_content_creator: www.thorbiq.com; RSen_C_content_date_changed: 31/07/2018; RSen_C_content_date_issue: 31/07/2018; RSen_C_content_provider: JAGA N.V.; RSen_C_content_version: 1.1.0; RSen_C_description: jaga_clima canal hybrid_trench radiator; RSen_C_IFC_version: 2x3; RSen_C_license: Creative Commons Attribution NoDerivs (CC-ND); RSen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSen_C_model: Clima Canal Hybrid; RSen_C_revit_version: 2016; RSen_C_type: Hybrid; RSen_C_type_comments: trench radiator; TBQ_I BaseKeynote: 56.10.60.11; Type Comments: trench radiator; Type Name: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4; URL: www.jaga.be
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 154 134 117 T00 wood BNN_gen; TBQ_I Colour: wood natural color; TBQ_I Colour chart: BNN
Type - Mechanical - RSen_P_c03_load_value: 0
Type - Model Properties - RSen_C_volume: 0 m3; RSen_S_weight_net: 0; TBQ_I Depth_cm: 18; TBQ_I Height_cm: 10; TBQ_I Length_cm: 72; TBQ_I Mounting accessories: -
Type - Other - Category: Mechanical Equipment; Family Name: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga; RSen_E_c01_description: c01_el; RSen_E_c01_power_factor_state: Lagging; RSen_E_c01_system_type: Power - Balanced; RSen_E_c01_yes_no: yes; RSen_E_c02_description: c02_control; RSen_E_c02_yes_no: yes; RSen_M_c01_description: c01_supply air; RSen_M_c01_diameter: 0 mm; RSen_M_c01_flow_configuration: Preset; RSen_M_c01_flow_direction: In; RSen_M_c01_height: 40 mm; RSen_M_c01_loss_method: Not Defined; RSen_M_c01_optional: yes; RSen_M_c01_shape: Rectangular; RSen_M_c01_system_classification: Supply Air; RSen_M_c01_width: 88 mm; RSen_M_c01_yes_no: yes; RSen_P_c01_description: c01_Central Heating Supply; RSen_P_c01_flow_configuration: Hydronic Supply; RSen_P_c01_flow_direction: Preset; RSen_P_c01_loss_method: Not Defined; RSen_P_c01_system_classification: In; RSen_P_c01_yes_no: yes; RSen_P_c02_description: c02_Central Heating Return; RSen_P_c02_flow_configuration: Hydronic Return; RSen_P_c02_flow_direction: Calculated; RSen_P_c02_loss_method: Not Defined; RSen_P_c02_system_classification: Out; RSen_P_c02_yes_no: yes; RSen_P_c03_description: c03_drain; RSen_P_c03_diameter: 20 mm; RSen_P_c03_flow_configuration: Fixture Units; RSen_P_c03_flow_direction: Out; RSen_P_c03_loss_method: Not Defined; RSen_P_c03_system_classification: Sanitary; RSen_P_c03_yes_no: yes
Pset_DistributionFlowElementCommon - Reference: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga:clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_ProductRequirements - Category: Mechanical Equipment
Constraints - Elevation: 0 mm; Host: Reference Plane : h_leftright
Construction - RSen_C_accessory_ME_01: none_gen; RSen_C_accessory_ME_02: none_gen; RSen_C_accessory_ME_03: none_gen; RSen_C_accessory_ME_04: none_gen; RSen_C_accessory_ME_05: none_gen; RSen_C_alignment: Center; RSen_C_alignment_index: 0; RSen_C_connection_CHr_position: Left; RSen_C_connection_CHr_position_index: 6; RSen_C_connection_CHs_position: Left; RSen_C_connection_CHs_position_index: 6; RSen_C_connection_possibilities: Left; RSen_C_connection_possibilities_index: 1; RSen_C_connection_set_CHr: RSen_56_ME_FB_CHr - connection set - SH_jaga: none; RSen_C_connection_set_CHs: RSen_56_ME_FB_CHs - connection set - SH_jaga: none; RSen_C_offset_from_base_level: 0 mm; RSen_C_thermostatic_head_index: no; RSen_C_thermostatic_head_position: Not selected; RSen_C_thermostatic_head_position_index: 0; RSen_C_thermostatic_head_type: RSen_56_ME_FB_thermostatic head - SH_thorbiq: standard; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 6.99262 m2; Volume: 0.859599 m3
Energy Analysis - TBQen_M_cooling_output_sensible_for_16_18_27: 1547.14; TBQen_M_current_heat_output_for_applied_regime: 10763.9; TBQen_M_current_heat_output_for_applied_regime_index: 3; TBQen_M_current_heat_output_for_applied_regime_info: 8V; TBQen_M_heat_output_for_75_65_20: 9578.51; TBQen_M_max_cooling_output_for_applied_regime: 2490.9; TBQen_M_max_heat_output_for_applied_regime: 5747.11; TBQen_M_temperature_cooling: 27 kg/K/s3; TBQen_M_temperature_cooling_return: 12 kg/K/s3; TBQen_M_temperature_cooling_supply: 7 kg/K/s3; TBQen_M_temperature_heating: 20 kg/K/s3; TBQen_M_temperature_heating_return: 45 kg/K/s3; TBQen_M_temperature_heating_supply: 55 kg/K/s3
Graphics - RSen_C_clearance_zone: no; RSen_C_connection_zone: no; RSen_C_maintenance_zone: no; RSen_C_neighbour_unit: no; RSen_C_neighbour_unit_displacement_back: 0 mm; RSen_C_neighbour_unit_displacement_front: 0 mm; RSen_C_neighbour_unit_displacement_left: 0 mm; RSen_C_neighbour_unit_displacement_right: 0 mm; TBQen_C_logo: yes
Identity Data - Mark: 1507
Mechanical - RSen_M_c01_flow_rate: 0 m3/s; RSen_P_c01_volume_flow: 0.000422 m3/s; RSen_P_c02_volume_flow: 0.000422 m3/s; RSen_P_nominal_diameter_return: 15 mm; RSen_P_nominal_diameter_supply: 15 mm; System Classification: Power,Controls,Supply Air,Sanitary,Hydronic Supply,Hydronic Return
Mechanical - Flow - RSen_M_flow_rate: 0 m3/s
Model Properties - RSen_C_thermostatic_head: Not selected
Other - Family: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4; Family and Type: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4; RSen_P_c01_diameter: 15 mm; RSen_P_c01_temperature: 55 kg/K/s3; RSen_P_c02_diameter: 15 mm; RSen_P_c02_temperature: 45 kg/K/s3; Type: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4; Type Id: RSen_56_ME_FB_radiator - hybrid - fresh air intake_jaga: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: -
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcSpaceHeaterType, no part of this type: clcm.01007218.bnn - wood natural color_jaga_clima canal hybrid_lxhxd 723x101,4x180,4
PredefinedType: CONVECTOR; Classification: 56.10.60.11 (Uniformat); Material: RSen_x_rgb 154 134 117 T00 wood BNN_gen
